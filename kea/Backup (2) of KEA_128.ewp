# IAR project Backup (2) of KEA_128.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: KEAZ128xxx4 Freescale KEAZ128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: IAR; TRK_KEA128; CPU_KEA128
  ICCARM.CCIncludePath2: src\common; user; src\fun; src\cpu; src\cpu\headers; src\platforms; src\projects\inc; src\Project_Headers; src\drivers; src\drivers\uart; src\drivers\wdog; src\drivers\sim; src\drivers\ics; src\drivers\gpio; src\drivers\pit; src\drivers\adc; src\drivers\uart; src\drivers\ftm; src\drivers\kbi; src\drivers\iic; src\drivers\spi; src\landzo; $TOOLKIT_DIR$\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: KEA_128.srec
  ILINK.IlinkOutputFile: KEA_128.out
  ILINK.IlinkIcfFile: config_files\128KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    src/APP/: isr.c main.c
  group common
    src/common/: assert.c common.h io.c memtest.c printf.c queue.c startup.c
  group cpu
    src/cpu/: arm_cm0.c crt0.s include.h isr.h start.c sysinit.c system_SKEAZ1284.h systick.c vectors.c
  group drivers
    src/drivers/adc/: adc.c
    src/drivers/ftm/: ftm.c
    src/drivers/gpio/: gpio.c GPIO_icf.h
    src/drivers/iic/: i2c.c
    src/drivers/ics/: ics.c
    src/drivers/kbi/: kbi.c
    src/drivers/motor/: motor.c
    src/drivers/pit/: pit.c
    src/drivers/sim/: sim.c
    src/drivers/spi/: spi.c
    src/drivers/steer/: steer.c
    src/drivers/uart/: uart.c
    src/drivers/wdog/: wdog.c
  group fun
    src/fun/: fun.c fun.h OLED.c OLED.h
  group platforms
    src/platforms/: kea128_config.h
  group user
    user/: headfile.h
